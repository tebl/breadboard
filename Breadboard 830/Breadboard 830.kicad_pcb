File: Breadboard 830/Breadboard 830.kicad_pcb (KiCad board)
At the start: 2 copper layers, 165.1 x 53.3 mm, 91 parts

Commit message: Gerber export
Other:
- rule pad_to_mask_clearance: 0.051 -> 0
